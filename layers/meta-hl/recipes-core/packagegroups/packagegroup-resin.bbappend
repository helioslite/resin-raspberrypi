
RDEPENDS_${PN}_append = " hl-host-controll hl-rsm"
